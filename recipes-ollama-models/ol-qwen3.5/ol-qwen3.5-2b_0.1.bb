require ol-qwen3.5.inc

MODEL_TAG = "2b"

MANIFEST_SHA256 = "324d162be6ca5629ae4517c8710434d0bd2d665bc94dbad46e9af8fbf8a2f0df"
IMAGE_JSON_SHA256 = "ee043a99abe5e8317272712ed08ee2993af1f7930d69aefa3eba562cdc2822bd"
MODEL_SHA256 = "b709d81508a078a686961de6ca07a953b895d9b286c46e17f00fb267f4f2d297"
